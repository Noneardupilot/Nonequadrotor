# Keil uVision project FlightControllerV1.0.uvprojx, settings and files
target Flight_Controller_V1.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FlightControllerV1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c misc: --cpp11
  c include: ..\Application;..\Drivers;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Protocol;..\Readme;..\Core;..\User
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: arducopter.cpp copter.cpp scheduler.cpp system.cpp board.cpp
  group Application
    ../Application/: pid.cpp adrc.cpp imu.cpp
  group Drivers
    ../Drivers/: dev_led.cpp dev_rgbled.cpp dev_const_led.cpp dev_ws2812.cpp dev_uart.cpp dev_soft_iic.cpp dev_hard_iic.cpp dev_mpu6000.cpp dev_mpu6050.cpp dev_mpu6500.cpp dev_mpu9250.cpp dev_mpu9150.cpp dev_icm_20602.cpp dev_spl06.cpp dev_hmc5883l.cpp dev_ist8310.cpp dev_spi.cpp dev_lsm303d.cpp dev_l3gd20.cpp dev_can.cpp dev_sdcard.cpp dev_gps.cpp dev_pwm.cpp dev_fm25v01.cpp dev_sbus.cpp dev_ppm.cpp dev_motor.cpp dev_sensor.cpp dev_ms5611.cpp
  group Protocol
    ../Protocol/: protocol.cpp
  group Core
    ../Core/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f427_437xx.s
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Readme
    ../Readme/: readme.txt
